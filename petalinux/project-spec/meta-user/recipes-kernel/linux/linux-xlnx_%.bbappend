SRC_URI += "file://user_2019-02-12-14-28-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

